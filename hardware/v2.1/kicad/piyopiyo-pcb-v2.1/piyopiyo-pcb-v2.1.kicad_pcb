# Repository piyopiyoex/piyopiyo-pcb

File README.md:

# Piyopiyo PCB

Piyopiyo PCB は、Elixir 入門者コミュニティ
[piyopiyo.ex](https://piyopiyoex.connpass.com/) のためのオリジナル基板です。
ワークショップや自習で扱いやすく、回路やソフトウェアも後から読み解きやすい構成を目指しています。

## ハードウェア

ハードウェア設計データの概要や各ファイルの用途は、
[`hardware/README.md`](./hardware/) を参照してください。

## Attribution & Licensing

- ハードウェア設計（`hardware/`）: [kurokouji](https://github.com/kurokouji)
- `hardware/` は CERN-OHL-P-2.0、`manuals/` / `media/` / `.md` は原則 CC BY 4.0
- ライセンスの詳細: [`LICENSE.md`](./LICENSE.md)

## KiCad design hardware/v2.1/kicad/piyopiyo-pcb-v2.1/piyopiyo-pcb-v2.1.kicad_pcb

File hardware/README.md:

# hardware

`hardware/` には、Piyopiyo PCB のハードウェア設計データをまとめています。

主な内容は次のとおりです。

```text
hardware/
├── vX.Y/                         # バージョンごとの設計データ一式
│   ├── kicad/                    # KiCad プロジェクト一式（.kicad_pro/.kicad_sch/.kicad_pcb 等）
│   │   └── piyopiyo-pcb-vX.Y/    # プロジェクトフォルダ（フットプリント/ライブラリ含む）
│   ├── fab/
│   │   └── jlcpcb/               # JLCPCB 向け製造データ
│   │       ├── bom.csv           # 部品表（LCSC Part # を含む）
│   │       ├── cpl.csv           # 部品実装位置（Pick & Place）
│   │       └── gerber.zip        # 基板製造用 Gerber 一式
│   └── docs/
│       └── piyopiyo-pcb.pdf      # 回路図・基板レイアウトの PDF 出力
├── reference/                    # モジュール寸法などの参考資料
└── CHANGELOG.md                  # バージョン間の変更履歴
```

## ライセンスと帰属

このディレクトリのハードウェア設計データは kurokouji により作成されました。

ライセンスの詳細は [`LICENSE.md`](../LICENSE.md) を参照してください。

Parts:
C1, C2, C3, C4, C6, C10, C11, C12: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 1000P; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C13: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14: 22u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15, C16, C17, C18, C19, C20: 47u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J1: POWER; PinHeader_1x04_P2.54mm_Horizontal
J2: 1.9 LCD 7P; PinSocket_1x07_P2.54mm_Vertical
J3: Conn_01x14_Socket; PinSocket_1x14_P2.54mm_Vertical
J4: PIR; NS-Tech_Grove_1x04_P2mm_Vertical
J5: GROVE I2C; NS-Tech_Grove_1x04_P2mm_Vertical
J6: LCD SD 4P; PinSocket_1x04_P2.54mm_Vertical
J7: SD_CS; PinHeader_1x02_P2.54mm_Vertical
J8: SP_EN(D3); PinHeader_1x03_P2.54mm_Vertical
J9: SW_EN(D3); PinHeader_1x02_P2.54mm_Vertical
J10: BL_EN(D3); PinHeader_1x02_P2.54mm_Vertical
J11: LCD_DIN; PinHeader_1x02_P2.54mm_Vertical
J12: GROVE TX/RX; NS-Tech_Grove_1x04_P2mm_Vertical
LS1: UGSM23A
R1, R2, R4, R5, R9: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 47K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R7, R8: DNP; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: 10K; Potentiometer_ACP_CA6-H2,5_Horizontal
SW1: SW_D3; TVGP01-G73BB
SW2: SW_D9; TVGP01-G73BB
SW3: SW_D7; TVGP01-G73BB
U1: XIAO-ESP32S3; MOUDLE14P-SMD-2.54-21X17.8MM-S3
U2: AZ1117CH-3.3TRG1; SOT-223
U3: NJM2113M-ND; NJR-DMP8_NJR

Connections:
+3.3V: C2.1, C20.1, J1.2, U1.12 (3V3)
+3.3VP: C4.1, C9.1, C10.1, C11.1, C12.1, C13.1, C15.1, C16.1, C17.1, C18.1, J1.3, J2.6, J3.14, J4.2, J5.2, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, U2.2 (OUTPUT), U2.4 (EPAD), U3.6 (V+)
+5V: C1.1, C3.1, C14.1, C19.1, J1.4, U1.14 (5V), U2.3 (INPUT)
/BL_EN: J2.1, J3.7, J10.1, R9.2
/CS: J3.12, U1.4 (PA11_A3_D3)
/PENIRQ: J3.1
/RESET: J2.3, J3.11, U1.2 (PA4_A1_D1)
/RS: J2.2, J3.10, U1.3 (PA10_A2_D2)
/SCL: J2.5, J3.5, J3.8, J6.4, U1.9 (PA7_A8_D8_SCK)
/SDA(MOSI): J2.4, J3.3, J3.9, J6.2, U1.11 (PA6_A10_D10_MOSI)
/SDO(MISO): J3.6, J11.2
/TX: J7.1, J8.1, J9.2, J10.2, J12.4, U1.7 (PB08_A6_D6_TX)
/T_CS(RX): J3.4, J12.3, R6.2, SW3.2, SW3.3, U1.8 (PB09_A7_D7_RX)
/T_DOUT: J3.2, J6.3, J11.1, R7.2, SW2.2, SW2.3, U1.10 (PA5_A9_D9_MISO)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, J1.1, J2.7, J3.13, J4.1, J5.1, J8.3, J12.1, RV1.1, SW1.1, SW1.4, SW2.1, SW2.4, SW3.1, SW3.4, U1.13 (GND), U2.1 (ADJ/GND), U3.7 (GND)
unnamed: C5.1, R1.2, RV1.3
unnamed: C6.1, RV1.2
unnamed: C6.2, R2.1
unnamed: J4.4, J9.1, R8.2, SW1.2, SW1.3
unnamed: J5.3, R4.2, U1.5 (PA8_A4_D4_SDA)
unnamed: J5.4, R5.2, U1.6 (PA9_A5_D5_SCL)
unnamed: J6.1, J7.2
unnamed: J8.2, U3.1 (CD)
unnamed: R1.1, U1.1 (PA02_A0_D0)
unnamed: C7.1, U3.3 (VIN+)
unnamed: R2.2, R3.1, U3.4 (VIN-)
unnamed: LS1.1, R3.2, U3.5 (VOUT1)
unnamed: LS1.2, U3.8 (VOUT2)
unnamed: C8.1, U3.2 (VREF)

Notes on the sheet:
MFR.Part # TAJB226M010RNJ JLCPCB Part # C89246
I2C
ビルトインLEDは Pin21に接続済
レギュレータ未使用の場合はJ1の2-3をショート RV1はTSR-3362-W-103-Rを実装すること。 テストポイントを付ける。 ユニバーサルエリアを作る。
LCD(SPI) 1.9インチ
SPEAKER-ENABLEでコントロールしない場合はLレベルGNDにショート。 CD 端子(1 pin)が Low レベル(<0.8V)の場合に動作状態、High レベル(>2.0V)の場合にスタンバイ状態になります。 アンテナを取り付けるためのマウント部品を用意する。 ※D3にLEDを付ける。 ※RTCとリチュームバッテリーを付けたい。 ※スピーカを小型のものに変えたい、音が消えるときの破裂音を消したい。
LCD(SPI) TOUCH PANEL 2.8インチ 320x240 SPI 50.0 x 86.2mm 3.5インチ 480x320 SPI 56.34 x 98mm
J12にTX/RXを接続
SDカードソケット

Board: 2 copper layers, 100.0 x 56.0 mm, 49 parts (0 on the bottom side), 28 nets.

File hardware/piyopiyo-pcb.v1.7.bom_jlcpcb.csv:

Comment,Designator,Footprint,LCSC,Quantity
0.1u,"C3,C4,C6",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C14663,3
1000P,C5,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C1588,1
10K,"R1,R2,R4,R5,R9",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C25804,5
10u,"C1,C10,C11,C12,C13,C14,C2,C9",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C19702,8
1u,C7,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C15849,1
4.7u,C8,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C19666,1
47K,R3,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C25819,1
47u,C15,C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,C16780,1
AZ1117CH-3.3TRG1,U2,SOT-223,C92102,1
Conn_01x14_Socket,J3,PinSocket_1x14_P2.54mm_Vertical,,1
DNP,R6,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
SW_D7,SW3,TVGP01-G73BB,,1
DNP,R8,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
LCD SD 4P,J6,PinSocket_1x04_P2.54mm_Vertical,,1
NJM2113M-ND,U3,NJR-DMP8_NJR,,1
DNP,R7,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,,1
SW_D3,SW1,TVGP01-G73BB,,1
SP_EN(D3),J8,PinHeader_1x03_P2.54mm_Vertical,,1
POWER,J1,PinHeader_1x04_P2.54mm_Horizontal,,1
UGSM23A,LS1,UGSM23A,,1
SW_D9,SW2,TVGP01-G73BB,,1
SD_CS,J7,PinHeader_1x02_P2.54mm_Vertical,,1
XIAO-ESP32S3,U1,MOUDLE14P-SMD-2.54-21X17.8MM-S3,,1
GROVE I2C,J5,NS-Tech_Grove_1x04_P2mm_Vertical,,1
10K,RV1,"Potentiometer_ACP_CA6-H2,5_Horizontal",,1
1.9 LCD 7P,J2,PinSocket_1x07_P2.54mm_Vertical,,1
BL_EN(D3),J10,PinHeader_1x02_P2.54mm_Vertical,,1
SW_EN(D3),J9,PinHeader_1x02_P2.54mm_Vertical,,1
LCD_DIN,J11,PinHeader_1x02_P2.54mm_Vertical,,1
PIR,J4,NS-Tech_Grove_1x04_P2mm_Vertical,,1
hole_m3,REF**,hole_m3,,1
GROVE TX/RX,J12,NS-Tech_Grove_1x04_P2mm_Vertical,,1

## Commit log

2025-12-03 ハードウェア一式・画像・最小限のドキュメントを追加
    KiCad プロジェクト、BOM/CPL、PDF、参考資料などを `hardware/` 以下に追加。
    基板写真を `media/` に配置し、各ディレクトリに最小限の README を整備。
    トップレベルの README と .gitignore も更新。
2025-12-15 Add LICENSE.md
2025-12-16 README.md の文言変更
2026-01-17 Add v1.9 and organize files by version
2026-01-18 v1.9 ドキュメント追加とフォルダ構成整理
2026-03-10 XIAOアンテナ用の羽子板3Dデータ追加
2026-03-10 v2.1 ドキュメント追加
2026-03-31 docs(hardware): add v2.1 community parts list
